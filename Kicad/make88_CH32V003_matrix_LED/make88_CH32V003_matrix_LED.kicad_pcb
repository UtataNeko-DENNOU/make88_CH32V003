# Repository UtataNeko-DENNOU/make88_CH32V003

File README.md:

# make88_CH32V003 — ボタン電池で文字が流れる！8×8マトリクスLEDガジェット

## 📖 概要
技術書典頒布誌『**ボタン電池で文字が流れる！極小LEDガジェット製作記 ―― 8×8ダイナミック点灯の奥深き世界と自作ひらがなフォント制御**』（サークル：**電脳好奇心** / 著者：**うたたねこ**）の公式サポートリポジトリです[cite: 9, 13, 20]。

本書で解説した Arduino スケッチ一式、自作フォント定義ファイル、および 3D プリント用ケースデータ（STL）を公開しています[cite: 20]。

---

## 📁 リポジトリ構成・収録ファイル一覧

```text
make88_CH32V003/
├── README.md                                          # 本ドキュメント
├── STL/                                               # 専用3Dプリントケース STLデータ一式[cite: 20]
│   ├── CaseBody.stl                                   # ケース本体[cite: 21]
│   ├── SpacerFrameWithBridge.stl                      # プッシュボタン一体型スペーサー枠[cite: 21]
│   └── SlideLid.stl                                   # スライド式裏蓋[cite: 21]
└── ArduinoIDE/                                        # Arduinoスケッチ・フォントデータ
    ├── make88_CH32V003_matrix_PD7/                    # 【事前準備】PD7(NRST)のGPIO化ツール
    ├── make88_CH32V003_matrix_led_all_patterns/       # 【第3章】総合動作確認テスト
    ├── make88_CH32V003_matrix_longpress_gauge/        # 【第3章】1ボタン長押しゲージデモ
    ├── make88_CH32V003_matrix_photo_display/          # 【展示用】静止パターン切り替え表示
    └── make88_CH32V003_matrix_scroll_complete/        # 【第4章】ひらがな・英数スクロール完全版
        ├── make88_CH32V003_matrix_scroll_complete.ino # メインスケッチ[cite: 15]
        ├── font_data.h                                # 記号・数字・ひらがな・長音符フォント
        └── font_abc_data.h                            # 6列幅 英大文字・小文字フォント[cite: 9, 15]

```

### スケッチ役割一覧

| スケッチ / ファイル名 | 書籍対応 | 概要・用途 | 
| ----- | ----- | ----- | 
| `make88_CH32V003_matrix_PD7.ino` | **事前準備** | リセット端子（NRST）を LED 行ドライブ（`PD7`）へ切り替える Option Byte 設定ツール | 
| `make88_CH32V003_matrix_led_all_patterns.ino` | **第3章** | 実装後の極性・不点灯・短絡・電源耐性をボタン1つで検証する総合テスト | 
| `make88_CH32V003_matrix_longpress_gauge.ino` | **第3章** | 1ボタン操作用の長押しプログレスゲージ＆達成演出デモ | 
| `make88_CH32V003_matrix_photo_display.ino` | **展示・撮影** | 静止パターン（ドット絵・文字）をボタンで順送り表示するデモコード | 
| `make88_CH32V003_matrix_scroll_complete.ino` | **第4章** | ひらがな（濁点・半濁点分離合成）・英数字の混在スクロール表示完全版 | 

## 🛠️ ハードウェア仕様・ピンアサイン

* **マイコン**: WCH `CH32V003F4P6`（32-bit RISC-V / TSSOP-20 / Flash 16KB / SRAM 2KB）

* **LEDマトリクス**: 8×8 ドット（1608サイズ SMD LED × 64個 / 1/8 ダイナミック点灯）

* **電源**: CR2032 コイン電池（3.0V）＋ 物理電源スイッチ（`SW1`）

* **入力**: プッシュタクトスイッチ（`PSW1`）

### GPIO ピン割り当て

| 機能 | 割り当てピン（順） | 論理・備考 | 
| ----- | ----- | ----- | 
| **行ピン（Row 0〜7 / 上→下）** | `PA1`, `PD7`, `PD6`, `PD5`, `PD4`, `PD3`, `PD2`, `PD0` | カソード側（LOW アクティブ）  ※`PA1` はリマップ、`PD7` は事前GPIO化が必要 | 
| **列ピン（Col 0〜7 / 左→右）** | `PC1`, `PC2`, `PC3`, `PC4`, `PC5`, `PC6`, `PC7`, `PA2` | アノード側（HIGH アクティブ）  ※`PA2` はリマップが必要 | 
| **プッシュスイッチ（PSW1）** | `PC0` | 内部プルアップ入力（LOW アクティブ） | 
| **SWD 書き込み端子（J2）** | `SWDIO (PD1)`, `3.3V`, `GND` | 3線接続（**※5V印加厳禁**） | 

## 💻 環境構築・書き込み手順

### 1. Arduino IDE のセットアップ

1. Arduino IDE の **「ファイル」→「基本設定」** を開き、「追加のボードマネージャのURL」に以下を追加します。

   ```
   https://github.com/openwch/board_manager_files/raw/main/package_ch32v_index.json
   
   ```

2. **「ツール」→「ボード」→「ボードマネージャ」** で `CH32` を検索し、**`CH32 MCU EVT Boards`** をインストールします。

3. 「ツール」メニューから以下のように設定します。

   * **Board**: `CH32V00x`

   * **Chip Series**: `CH32V003`

   * **CPU Frequency**: `24MHz (HSI)`（※ボタン電池駆動向けの省電力設定）

   * **Upload Method**: `WCH-SWD`

### 2. WCH-LinkE での書き込み（重要注意事項）

> \[!CAUTION\]
> **電源電圧は必ず「3.3V」を使用してください。**
>
> 本基板に 5V を供給すると LED 回路に過電圧がかかり破損の原因になります。

1. **WCH-LinkE のモード確認**: PC 接続時に本体上の **青色LEDが消灯（RVモード）** していることを確認してください（点灯している場合は ARM モードのため、`ModeSelect` ボタンを押しながら再接続または `WCH-LinkUtility` で `WCH-LinkRV` に切り替えます）。

2. **初回のみの事前準備**: 最初に `make88_CH32V003_matrix_PD7.ino` を書き込み、リセット端子（NRST）を `PD7`（Row 1）として解放してください。

3. **本編スケッチの書き込み**: その後、テストスケッチやスクロール完全版を書き込んで動作を確認します。

## 🔧 トラブルシューティング

* **2行目（Row 1）だけまったく点灯しない**

  * 出荷状態では `PD7` がリセットピン（NRST）になっています。先に `make88_CH32V003_matrix_PD7.ino` を書き込んで Option Byte を更新してください。

* **書き込み時にエラーが出る / デバッガが認識しない**

  * `WCH-LinkE` の配線（`SWDIO`, `3.3V`, `GND`）と、電源スイッチ（`SW1`）の状態、および WCH-LinkE が **RVモード（青LED消灯）** になっているか確認してください。

  * `PD7` を GPIO 化した後に書き込みが通らなくなった場合は、公式ツール `WCH-LinkUtility` の **「Target」→「Erase Code Flash」**（電源投入直後の接続）で初期化できます。

## 📝 正誤表・アップデート情報（Errata）

* 初版発行後の修正情報やファームウェアのアップデートは随時ここに追記します。

## 📄 ライセンス

本プロジェクト（回路図、基板データ、3Dモデルデータ、およびファームウェア）は、個人による学習・趣味の電子工作・改変を目的として公開しています。

- **ライセンス**: [CC BY-NC-SA 4.0（クリエイティブ・コモンズ 表示 - 非営利 - 継承 4.0 国際）](https://creativecommons.org/licenses/by-nc-sa/4.0/deed.ja)

#### 許可されること
- 個人利用を目的とした基板製造、組み立て、3Dプリント
- ソースコードや3Dデータの改変・機能追加
- 改変したデータの非営利・同ライセンス下での共有

#### 禁止されること
- **商用利用・営利目的での利用**（完成品・組み立てキット・基板・3Dプリントパーツの販売や転売など）
- クレジット表記なしでの再配布

※イベント頒布や商用利用・共同開発等をご希望の場合は、事前にご連絡ください。

* 書籍本文および回路図・3Dデータの無断転載・商用再配布はご遠慮ください。

* Copyright (c) 電脳好奇心 / うたたねこ

## KiCad design Kicad/make88_CH32V003_matrix_LED/make88_CH32V003_matrix_LED.kicad_pcb

Parts:
BT1: Battery_Cell; BatteryHolder_Keystone_1060_1x2032
C1: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
CS1: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC C28323
J2: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
PSW1: SW_Push; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816; LCSC C139797
R8: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C14675
SW1: SW_SPDT; PinHeader_1x03_P2.54mm_Vertical
U1: CH32V003FxPx; TSSOP-20_4.4x6.5mm_P0.65mm

Connections:
/3V: J2.3, SW1.3 (C)
/5V: J2.4
/PA1_ROW1: U1.5 (PA1); also elsewhere on the board
/PA2_COL8: U1.6 (PA2); also elsewhere on the board
/PC1_COL1: U1.11 (PC1); also elsewhere on the board
/PC2_COL2: U1.12 (PC2); also elsewhere on the board
/PC3_COL3: U1.13 (PC3); also elsewhere on the board
/PC4_COL4: U1.14 (PC4); also elsewhere on the board
/PC5_COL5: U1.15 (PC5); also elsewhere on the board
/PC6_COL6: U1.16 (PC6); also elsewhere on the board
/PC7_COL7: U1.17 (PC7); also elsewhere on the board
/PD0_ROW8: U1.8 (PD0); also elsewhere on the board
/PD2_ROW7: U1.19 (PD2); also elsewhere on the board
/PD3_ROW6: U1.20 (PD3); also elsewhere on the board
/PD4_ROW5: U1.1 (PD4); also elsewhere on the board
/PD5_ROW4: U1.2 (PD5); also elsewhere on the board
/PD6_ROW3: U1.3 (PD6); also elsewhere on the board
/PD7_ROW2: U1.4 (PD7); also elsewhere on the board
/SWDIO: J2.1, U1.18 (PD1)
/VBAT: BT1.1 (+), SW1.1 (A)
/VDD: C1.1, C2.1, R8.1, SW1.2 (B), U1.9 (VDD)
GND: BT1.2 (-), C1.2, C2.2, CS1.2, J2.2, PSW1.2, U1.7 (VSS)
unnamed: CS1.1, PSW1.1, R8.2, U1.10 (PC0)

Notes on the sheet:
Push Switch
CH32V003 マイコン
電源供給選択

Parts:
LEDD0, LEDD1, LEDD2, LEDD3, LEDD4, LEDD5, LEDD6, LEDD7: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C965807

Connections:
/PA2_COL8: LEDD7.2 (A); also elsewhere on the board
/PC1_COL1: LEDD0.2 (A); also elsewhere on the board
/PC2_COL2: LEDD1.2 (A); also elsewhere on the board
/PC3_COL3: LEDD2.2 (A); also elsewhere on the board
/PC4_COL4: LEDD3.2 (A); also elsewhere on the board
/PC5_COL5: LEDD4.2 (A); also elsewhere on the board
/PC6_COL6: LEDD5.2 (A); also elsewhere on the board
/PC7_COL7: LEDD6.2 (A); also elsewhere on the board
/PD5_ROW4: LEDD0.1 (K), LEDD1.1 (K), LEDD2.1 (K), LEDD3.1 (K), LEDD4.1 (K), LEDD5.1 (K), LEDD6.1 (K), LEDD7.1 (K); also elsewhere on the board

Parts:
LEDG0, LEDG1, LEDG2, LEDG3, LEDG4, LEDG5, LEDG6, LEDG7: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C965807

Connections:
/PA2_COL8: LEDG7.2 (A); also elsewhere on the board
/PC1_COL1: LEDG0.2 (A); also elsewhere on the board
/PC2_COL2: LEDG1.2 (A); also elsewhere on the board
/PC3_COL3: LEDG2.2 (A); also elsewhere on the board
/PC4_COL4: LEDG3.2 (A); also elsewhere on the board
/PC5_COL5: LEDG4.2 (A); also elsewhere on the board
/PC6_COL6: LEDG5.2 (A); also elsewhere on the board
/PC7_COL7: LEDG6.2 (A); also elsewhere on the board
/PD2_ROW7: LEDG0.1 (K), LEDG1.1 (K), LEDG2.1 (K), LEDG3.1 (K), LEDG4.1 (K), LEDG5.1 (K), LEDG6.1 (K), LEDG7.1 (K); also elsewhere on the board

Parts:
LEDC0, LEDC1, LEDC2, LEDC3, LEDC4, LEDC5, LEDC6, LEDC7: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C965807

Connections:
/PA2_COL8: LEDC7.2 (A); also elsewhere on the board
/PC1_COL1: LEDC0.2 (A); also elsewhere on the board
/PC2_COL2: LEDC1.2 (A); also elsewhere on the board
/PC3_COL3: LEDC2.2 (A); also elsewhere on the board
/PC4_COL4: LEDC3.2 (A); also elsewhere on the board
/PC5_COL5: LEDC4.2 (A); also elsewhere on the board
/PC6_COL6: LEDC5.2 (A); also elsewhere on the board
/PC7_COL7: LEDC6.2 (A); also elsewhere on the board
/PD6_ROW3: LEDC0.1 (K), LEDC1.1 (K), LEDC2.1 (K), LEDC3.1 (K), LEDC4.1 (K), LEDC5.1 (K), LEDC6.1 (K), LEDC7.1 (K); also elsewhere on the board

Parts:
LEDB0, LEDB1, LEDB2, LEDB3, LEDB4, LEDB5, LEDB6, LEDB7: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C965807

Connections:
/PA2_COL8: LEDB7.2 (A); also elsewhere on the board
/PC1_COL1: LEDB0.2 (A); also elsewhere on the board
/PC2_COL2: LEDB1.2 (A); also elsewhere on the board
/PC3_COL3: LEDB2.2 (A); also elsewhere on the board
/PC4_COL4: LEDB3.2 (A); also elsewhere on the board
/PC5_COL5: LEDB4.2 (A); also elsewhere on the board
/PC6_COL6: LEDB5.2 (A); also elsewhere on the board
/PC7_COL7: LEDB6.2 (A); also elsewhere on the board
/PD7_ROW2: LEDB0.1 (K), LEDB1.1 (K), LEDB2.1 (K), LEDB3.1 (K), LEDB4.1 (K), LEDB5.1 (K), LEDB6.1 (K), LEDB7.1 (K); also elsewhere on the board

Parts:
LEDE0, LEDE1, LEDE2, LEDE3, LEDE4, LEDE5, LEDE6, LEDE7: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C965807

Connections:
/PA2_COL8: LEDE7.2 (A); also elsewhere on the board
/PC1_COL1: LEDE0.2 (A); also elsewhere on the board
/PC2_COL2: LEDE1.2 (A); also elsewhere on the board
/PC3_COL3: LEDE2.2 (A); also elsewhere on the board
/PC4_COL4: LEDE3.2 (A); also elsewhere on the board
/PC5_COL5: LEDE4.2 (A); also elsewhere on the board
/PC6_COL6: LEDE5.2 (A); also elsewhere on the board
/PC7_COL7: LEDE6.2 (A); also elsewhere on the board
/PD4_ROW5: LEDE0.1 (K), LEDE1.1 (K), LEDE2.1 (K), LEDE3.1 (K), LEDE4.1 (K), LEDE5.1 (K), LEDE6.1 (K), LEDE7.1 (K); also elsewhere on the board

Parts:
LEDF0, LEDF1, LEDF2, LEDF3, LEDF4, LEDF5, LEDF6, LEDF7: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C965807

Connections:
/PA2_COL8: LEDF7.2 (A); also elsewhere on the board
/PC1_COL1: LEDF0.2 (A); also elsewhere on the board
/PC2_COL2: LEDF1.2 (A); also elsewhere on the board
/PC3_COL3: LEDF2.2 (A); also elsewhere on the board
/PC4_COL4: LEDF3.2 (A); also elsewhere on the board
/PC5_COL5: LEDF4.2 (A); also elsewhere on the board
/PC6_COL6: LEDF5.2 (A); also elsewhere on the board
/PC7_COL7: LEDF6.2 (A); also elsewhere on the board
/PD3_ROW6: LEDF0.1 (K), LEDF1.1 (K), LEDF2.1 (K), LEDF3.1 (K), LEDF4.1 (K), LEDF5.1 (K), LEDF6.1 (K), LEDF7.1 (K); also elsewhere on the board

Parts:
LEDH0, LEDH1, LEDH2, LEDH3, LEDH4, LEDH5, LEDH6, LEDH7: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C965807

Connections:
/PA2_COL8: LEDH7.2 (A); also elsewhere on the board
/PC1_COL1: LEDH0.2 (A); also elsewhere on the board
/PC2_COL2: LEDH1.2 (A); also elsewhere on the board
/PC3_COL3: LEDH2.2 (A); also elsewhere on the board
/PC4_COL4: LEDH3.2 (A); also elsewhere on the board
/PC5_COL5: LEDH4.2 (A); also elsewhere on the board
/PC6_COL6: LEDH5.2 (A); also elsewhere on the board
/PC7_COL7: LEDH6.2 (A); also elsewhere on the board
/PD0_ROW8: LEDH0.1 (K), LEDH1.1 (K), LEDH2.1 (K), LEDH3.1 (K), LEDH4.1 (K), LEDH5.1 (K), LEDH6.1 (K), LEDH7.1 (K); also elsewhere on the board

Schematic: LINE0.kicad_sch

Parts:
LEDA0, LEDA1, LEDA2, LEDA3, LEDA4, LEDA5, LEDA6, LEDA7: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C965807

Connections:
/PA1_ROW1: LEDA0.1 (K), LEDA1.1 (K), LEDA2.1 (K), LEDA3.1 (K), LEDA4.1 (K), LEDA5.1 (K), LEDA6.1 (K), LEDA7.1 (K); also elsewhere on the board
/PA2_COL8: LEDA7.2 (A); also elsewhere on the board
/PC1_COL1: LEDA0.2 (A); also elsewhere on the board
/PC2_COL2: LEDA1.2 (A); also elsewhere on the board
/PC3_COL3: LEDA2.2 (A); also elsewhere on the board
/PC4_COL4: LEDA3.2 (A); also elsewhere on the board
/PC5_COL5: LEDA4.2 (A); also elsewhere on the board
/PC6_COL6: LEDA5.2 (A); also elsewhere on the board
/PC7_COL7: LEDA6.2 (A); also elsewhere on the board

Board: 2 copper layers, 45.0 x 45.0 mm, 78 parts (6 on the bottom side), 22 nets.

Other parts of the board:
G6: LOGO; DENNOU01
REF1, REF2, REF3, REF4: MountingHole_2.2mm_M2

## KiCad design Kicad/make88_CH32V003_matrix_LED/___make81_CH32V003_matrix.kicad_pcb

Board: 2 copper layers, 90.0 x 40.0 mm, 104 parts (3 on the bottom side), 68 nets.

Parts:
BT1: Battery_Cell; BatteryHolder_ComfortableElectronic_CH273-2450_1x2450
C1, C6: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C3, C4, C5: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
CRST1: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
CX1, CX2: 24pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
G1: LOGO; DENNOU_QR
G6: LOGO; DENNOU01
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_G-Switch_GT-USB-7010ASV
LED1: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
LEDA0, LEDA1, LEDA2, LEDA3, LEDA4, LEDA5: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
LEDB0, LEDB1, LEDB2, LEDB3, LEDB4, LEDB5: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
LEDC0, LEDC1, LEDC2, LEDC3, LEDC4, LEDC5: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
LEDD1, LEDD2, LEDD3, LEDD4, LEDD5, LEDD6: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
LEDE1, LEDE2, LEDE3, LEDE4, LEDE5, LEDE6: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
LEDF1, LEDF2, LEDF3, LEDF4, LEDF5, LEDF6: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
PSW1, PSW2: SW_SPST; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
R1: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RA0, RA1, RA2, RA3, RA4, RA5: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RB0, RB1, RB2, RB3, RB4, RB5: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RC0, RC1, RC2, RC3, RC4, RC5: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RCC1, RCC2: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RD1, RD2, RD3, RD4, RD5, RD6: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RDLD1: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RE1, RE2, RE3, RE4, RE5, RE6: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
REF1, REF2, REF3, REF4: MountingHole_3.2mm_M3_DIN965
RF1, RF2, RF3, RF4, RF5, RF6: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RISET1: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RRST1: 330; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RU1, RU2: 0.1; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_SPDT; PinHeader_1x03_P2.54mm_Vertical
U1: Oscillator_SMD_EuroQuartz_XO32-4Pin_3.2x2.5mm_HandSoldering
U2: CH217K; TSOT-23-6_HandSoldering
U3: CH552T; SSOP-20_4.4x6.5mm_P0.65mm

Connections:
/CC1: J2.A5 (CC1), RCC1.1
/CC2: J2.B5 (CC2), RCC2.1
/DM: J2.A7 (D-), J2.B7 (D-), RU1.2
/DP: J2.A6 (D+), J2.B6 (D+), RU2.2
/FLAGB: R1.2, U2.3 (FLAGB)
/ISET: RISET1.1, U2.5 (ISET)
/P10: LEDA5.2 (A), LEDB5.2 (A), LEDC5.2 (A), LEDD6.2 (A), LEDE6.2 (A), LEDF6.2 (A), U3.7 (P1.0)
/P11: RA0.2, RA1.2, RA2.2, RA3.2, RA4.2, RA5.2, U3.8 (P1.1)
/P12: CX1.1, U1.1 (XIN), U3.17 (P1.2)
/P13: CX2.1, U1.3 (XOUT), U3.16 (P1.3)
/P14: LEDA1.2 (A), LEDB1.2 (A), LEDC1.2 (A), LEDD2.2 (A), LEDE2.2 (A), LEDF2.2 (A), U3.2 (P1.4)
/P15: LEDA2.2 (A), LEDB2.2 (A), LEDC2.2 (A), LEDD3.2 (A), LEDE3.2 (A), LEDF3.2 (A), U3.3 (P1.5)
/P16: LEDA3.2 (A), LEDB3.2 (A), LEDC3.2 (A), LEDD4.2 (A), LEDE4.2 (A), LEDF4.2 (A), U3.4 (P1.6)
/P17: LEDA4.2 (A), LEDB4.2 (A), LEDC4.2 (A), LEDD5.2 (A), LEDE5.2 (A), LEDF5.2 (A), U3.5 (P1.7)
/P30: RC0.2, RC1.2, RC2.2, RC3.2, RC4.2, RC5.2, U3.10 (P3.0)
/P31: RB0.2, RB1.2, RB2.2, RB3.2, RB4.2, RB5.2, U3.9 (P3.1)
/P32: LEDA0.2 (A), LEDB0.2 (A), LEDC0.2 (A), LEDD1.2 (A), LEDE1.2 (A), LEDF1.2 (A), U3.1 (P3.2)
/P33: RD1.2, RD2.2, RD3.2, RD4.2, RD5.2, RD6.2, U3.11 (P3.3)
/P34: RE1.2, RE2.2, RE3.2, RE4.2, RE5.2, RE6.2, U3.12 (P3.4)
/P35: RF1.2, RF2.2, RF3.2, RF4.2, RF5.2, RF6.2, U3.13 (P3.5)
/P36: RDLD1.1, RU2.1, U3.14 (P3.6)
/P37: RU1.1, U3.15 (P3.7)
/RST: CRST1.1, RRST1.1, U3.6 (RST)
/V5: C1.1, C2.1, LED1.2 (A), SW1.3 (C), U2.1 (VOUT)
/V33: C3.1, C4.1, PSW2.2 (B), U3.20 (V33)
/VBAT: BT1.1 (+), SW1.1 (A)
/VBUS: J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), U2.6 (VIN)
/VDD5: C5.1, C6.1, PSW1.2 (B), SW1.2 (B), U3.19 (VDD)
/common1/WA0: LEDA0.1 (K), RA0.1
/common1/WA1: LEDA1.1 (K), RA1.1
/common1/WA2: LEDA2.1 (K), RA2.1
/common1/WA3: LEDA3.1 (K), RA3.1
/common1/WA4: LEDA4.1 (K), RA4.1
/common1/WA5: LEDA5.1 (K), RA5.1
/common2/WB0: LEDB0.1 (K), RB0.1
/common2/WB1: LEDB1.1 (K), RB1.1
/common2/WB2: LEDB2.1 (K), RB2.1
/common2/WB3: LEDB3.1 (K), RB3.1
/common2/WB4: LEDB4.1 (K), RB4.1
/common2/WB5: LEDB5.1 (K), RB5.1
/common3/WC0: LEDC0.1 (K), RC0.1
/common3/WC1: LEDC1.1 (K), RC1.1
/common3/WC2: LEDC2.1 (K), RC2.1
/common3/WC3: LEDC3.1 (K), RC3.1
/common3/WC4: LEDC4.1 (K), RC4.1
/common3/WC5: LEDC5.1 (K), RC5.1
/common4/WD0: LEDD1.1 (K), RD1.1
/common4/WD1: LEDD2.1 (K), RD2.1
/common4/WD2: LEDD3.1 (K), RD3.1
/common4/WD3: LEDD4.1 (K), RD4.1
/common4/WD4: LEDD5.1 (K), RD5.1
/common4/WD5: LEDD6.1 (K), RD6.1
/common5/WE0: LEDE1.1 (K), RE1.1
/common5/WE1: LEDE2.1 (K), RE2.1
/common5/WE2: LEDE3.1 (K), RE3.1
/common5/WE3: LEDE4.1 (K), RE4.1
/common5/WE4: LEDE5.1 (K), RE5.1
/common5/WE5: LEDE6.1 (K), RE6.1
/common6/WF0: LEDF1.1 (K), RF1.1
/common6/WF1: LEDF2.1 (K), RF2.1
/common6/WF2: LEDF3.1 (K), RF3.1
/common6/WF3: LEDF4.1 (K), RF4.1
/common6/WF4: LEDF5.1 (K), RF5.1
/common6/WF5: LEDF6.1 (K), RF6.1
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, CRST1.2, CX1.2, CX2.2, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), RCC1.2, RCC2.2, RISET1.2, U1.2 (GND), U1.4 (GND), U2.2 (GND), U2.4 (ENB), U3.18 (GND)
unnamed: LED1.1 (K), R1.1
unnamed: PSW1.1 (A), RRST1.2
unnamed: PSW2.1 (A), RDLD1.2

## Code that names these connections

File ArduinoIDE/make88_CH32V003_matrix_longpress_gauge.ino/make88_CH32V003_matrix_longpress_gauge.ino.ino:

/**
 * @file    make88_CH32V003_matrix_longpress_gauge.ino
 * @brief   8x8 LED Matrix Single-Button Long-Press Progress Gauge
 * @target  CH32V003F4P6 (QingKe 32-bit RISC-V2A / TSSOP20)
 * @author  電脳好奇心@うたたねこ
 * @details
 *   1ボタンUIの操作性を高めるプログレスゲージ（長押し蓄積）の実装例。
 *   PC0のボタンを押している間、8x8マトリクスの下段から上段へバーが伸び、
 *   約2秒押し切ると満タン達成アニメーション（3回点滅）を発動します。
 *   途中でボタンを離した場合は即座にキャンセルされます。
 *
 * 【ハードウェア接続】
 *   - 行ピン: PA1, PD7, PD6, PD5, PD4, PD3, PD2, PD0 (カソード LOW)
 *   - 列ピン: PC1, PC2, PC3, PC4, PC5, PC6, PC7, PA2 (アノード HIGH)
 *   - ボタン: PC0 (PSW1 / LOWアクティブ)
 *
 * 【内部管理情報】
 *   - PCB Rev / Code ID: make88_102 
 * ============================================================================
 */

#include <Arduino.h>

// 行ピン (上端 PA1 → 下端 PD0)
const uint8_t rawPins[8] = { PA1, PD7, PD6, PD5, PD4, PD3, PD2, PD0 };

// 列ピン (左端 PC1 → 右端 PA2)
const uint8_t colPins[8] = { PC1, PC2, PC3, PC4, PC5, PC6, PC7, PA2 };

const uint8_t btnPin = PC0;

#define REMAP_REG (*(uint32_t *)0x40010004)

// 全消灯
void clearAll() {
  for (int i = 0; i < 8; i++) {
    digitalWrite(rawPins[i], HIGH);
    digitalWrite(colPins[i], LOW);
  }
}

// 下から currentLevel 行分をダイナミック点灯 (level: 0〜8)
void displayGauge(int level, unsigned long durationMs) {
  unsigned long start = millis();
  while (millis() - start < durationMs) {
    if (level == 0) {
      clearAll();
      delayMicroseconds(500);
      continue;
    }

    // 行7 (下端) から上に向かって点灯
    for (int row = 7; row >= (8 - level); row--) {
      for (int c = 0; c < 8; c++) digitalWrite(colPins[c], HIGH);
      digitalWrite(rawPins[row], LOW);
      delayMicroseconds(400);

      digitalWrite(rawPins[row], HIGH);
      for (int c = 0; c < 8; c++) digitalWrite(colPins[c], LOW);
    }
  }
}

void setup() {
  delay(500);
  REMAP_REG &= ~(1 << 15);

  for (int i = 0; i < 8; i++) {
    pinMode(rawPins[i], OUTPUT);
    pinMode(colPins[i], OUTPUT);
  }
  pinMode(btnPin, INPUT);
  clearAll();
}

void loop() {
  // ボタンが押されているか確認 (LOW = 押下)
  if (digitalRead(btnPin) == LOW) {
    int gaugeLevel = 0;

    // ボタンを押している間、徐々にゲージを増やす（約2秒で満タン）
    while (digitalRead(btnPin) == LOW && gaugeLevel <= 8) {
      displayGauge(gaugeLevel, 250); // 1ステップあたり250ms
      gaugeLevel++;
    }

    // 8行すべて溜まった（長押し成功）場合のアクション
    if (gaugeLevel > 8) {
      // 達成のピカピカ点滅（3回）
      for (int k = 0; k < 3; k++) {
        displayGauge(8, 150);
        clearAll();
        delay(150);
      }
      // ボタンが離されるまで待機
      while (digitalRead(btnPin) == LOW);
      delay(50);
    }
  } else {
    // 待機中は消灯
    clearAll();
    delay(10);
  }
}
